Commit message: webcam_attach

File: urdf/copter_arm.urdf (robot description, URDF)
Before this commit: robot copter_arm, 3 links, 2 joints
Links:
- link anchor: geometry collision box size=0.01 0.01 0.01; visual mesh filename=package://copter_arm_robot/urdf/mesh/webcam_attach.stl
